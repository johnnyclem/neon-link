#include "neon/gfx/framebuffer.hpp"
#include "neon/gfx/font5x7.hpp"

#include <cstring>

namespace neon {

namespace {

constexpr auto& kFont5x7 = gfx::kFont5x7;

// Sentinel so the next line still parses if the table was left behind.
#if 0
constexpr uint8_t kFont5x7_unused[96][5] = {
    {0x00, 0x00, 0x00, 0x00, 0x00},  // ' '
    {0x00, 0x00, 0x5f, 0x00, 0x00},  // '!'
    {0x00, 0x07, 0x00, 0x07, 0x00},  // '"'
    {0x14, 0x7f, 0x14, 0x7f, 0x14},  // '#'
    {0x24, 0x2a, 0x7f, 0x2a, 0x12},  // '$'
    {0x23, 0x13, 0x08, 0x64, 0x62},  // '%'
    {0x36, 0x49, 0x55, 0x22, 0x50},  // '&'
    {0x00, 0x05, 0x03, 0x00, 0x00},  // '\''
    {0x00, 0x1c, 0x22, 0x41, 0x00},  // '('
    {0x00, 0x41, 0x22, 0x1c, 0x00},  // ')'
    {0x14, 0x08, 0x3e, 0x08, 0x14},  // '*'
    {0x08, 0x08, 0x3e, 0x08, 0x08},  // '+'
    {0x00, 0x50, 0x30, 0x00, 0x00},  // ','
    {0x08, 0x08, 0x08, 0x08, 0x08},  // '-'
    {0x00, 0x60, 0x60, 0x00, 0x00},  // '.'
    {0x20, 0x10, 0x08, 0x04, 0x02},  // '/'
    {0x3e, 0x51, 0x49, 0x45, 0x3e},  // '0'
    {0x00, 0x42, 0x7f, 0x40, 0x00},  // '1'
    {0x42, 0x61, 0x51, 0x49, 0x46},  // '2'
    {0x21, 0x41, 0x45, 0x4b, 0x31},  // '3'
    {0x18, 0x14, 0x12, 0x7f, 0x10},  // '4'
    {0x27, 0x45, 0x45, 0x45, 0x39},  // '5'
    {0x3c, 0x4a, 0x49, 0x49, 0x30},  // '6'
    {0x01, 0x71, 0x09, 0x05, 0x03},  // '7'
    {0x36, 0x49, 0x49, 0x49, 0x36},  // '8'
    {0x06, 0x49, 0x49, 0x29, 0x1e},  // '9'
    {0x00, 0x36, 0x36, 0x00, 0x00},  // ':'
    {0x00, 0x56, 0x36, 0x00, 0x00},  // ';'
    {0x08, 0x14, 0x22, 0x41, 0x00},  // '<'
    {0x14, 0x14, 0x14, 0x14, 0x14},  // '='
    {0x00, 0x41, 0x22, 0x14, 0x08},  // '>'
    {0x02, 0x01, 0x51, 0x09, 0x06},  // '?'
    {0x32, 0x49, 0x79, 0x41, 0x3e},  // '@'
    {0x7e, 0x11, 0x11, 0x11, 0x7e},  // 'A'
    {0x7f, 0x49, 0x49, 0x49, 0x36},  // 'B'
    {0x3e, 0x41, 0x41, 0x41, 0x22},  // 'C'
    {0x7f, 0x41, 0x41, 0x22, 0x1c},  // 'D'
    {0x7f, 0x49, 0x49, 0x49, 0x41},  // 'E'
    {0x7f, 0x09, 0x09, 0x09, 0x01},  // 'F'
    {0x3e, 0x41, 0x49, 0x49, 0x7a},  // 'G'
    {0x7f, 0x08, 0x08, 0x08, 0x7f},  // 'H'
    {0x00, 0x41, 0x7f, 0x41, 0x00},  // 'I'
    {0x20, 0x40, 0x41, 0x3f, 0x01},  // 'J'
    {0x7f, 0x08, 0x14, 0x22, 0x41},  // 'K'
    {0x7f, 0x40, 0x40, 0x40, 0x40},  // 'L'
    {0x7f, 0x02, 0x0c, 0x02, 0x7f},  // 'M'
    {0x7f, 0x04, 0x08, 0x10, 0x7f},  // 'N'
    {0x3e, 0x41, 0x41, 0x41, 0x3e},  // 'O'
    {0x7f, 0x09, 0x09, 0x09, 0x06},  // 'P'
    {0x3e, 0x41, 0x51, 0x21, 0x5e},  // 'Q'
    {0x7f, 0x09, 0x19, 0x29, 0x46},  // 'R'
    {0x46, 0x49, 0x49, 0x49, 0x31},  // 'S'
    {0x01, 0x01, 0x7f, 0x01, 0x01},  // 'T'
    {0x3f, 0x40, 0x40, 0x40, 0x3f},  // 'U'
    {0x1f, 0x20, 0x40, 0x20, 0x1f},  // 'V'
    {0x3f, 0x40, 0x38, 0x40, 0x3f},  // 'W'
    {0x63, 0x14, 0x08, 0x14, 0x63},  // 'X'
    {0x07, 0x08, 0x70, 0x08, 0x07},  // 'Y'
    {0x61, 0x51, 0x49, 0x45, 0x43},  // 'Z'
    {0x00, 0x7f, 0x41, 0x41, 0x00},  // '['
    {0x02, 0x04, 0x08, 0x10, 0x20},  // '\'
    {0x00, 0x41, 0x41, 0x7f, 0x00},  // ']'
    {0x04, 0x02, 0x01, 0x02, 0x04},  // '^'
    {0x40, 0x40, 0x40, 0x40, 0x40},  // '_'
    {0x00, 0x01, 0x02, 0x04, 0x00},  // '`'
    {0x20, 0x54, 0x54, 0x54, 0x78},  // 'a'
    {0x7f, 0x48, 0x44, 0x44, 0x38},  // 'b'
    {0x38, 0x44, 0x44, 0x44, 0x20},  // 'c'
    {0x38, 0x44, 0x44, 0x48, 0x7f},  // 'd'
    {0x38, 0x54, 0x54, 0x54, 0x18},  // 'e'
    {0x08, 0x7e, 0x09, 0x01, 0x02},  // 'f'
    {0x0c, 0x52, 0x52, 0x52, 0x3e},  // 'g'
    {0x7f, 0x08, 0x04, 0x04, 0x78},  // 'h'
    {0x00, 0x44, 0x7d, 0x40, 0x00},  // 'i'
    {0x20, 0x40, 0x44, 0x3d, 0x00},  // 'j'
    {0x7f, 0x10, 0x28, 0x44, 0x00},  // 'k'
    {0x00, 0x41, 0x7f, 0x40, 0x00},  // 'l'
    {0x7c, 0x04, 0x18, 0x04, 0x78},  // 'm'
    {0x7c, 0x08, 0x04, 0x04, 0x78},  // 'n'
    {0x38, 0x44, 0x44, 0x44, 0x38},  // 'o'
    {0x7c, 0x14, 0x14, 0x14, 0x08},  // 'p'
    {0x08, 0x14, 0x14, 0x18, 0x7c},  // 'q'
    {0x7c, 0x08, 0x04, 0x04, 0x08},  // 'r'
    {0x48, 0x54, 0x54, 0x54, 0x20},  // 's'
    {0x04, 0x3f, 0x44, 0x40, 0x20},  // 't'
    {0x3c, 0x40, 0x40, 0x20, 0x7c},  // 'u'
    {0x1c, 0x20, 0x40, 0x20, 0x1c},  // 'v'
    {0x3c, 0x40, 0x30, 0x40, 0x3c},  // 'w'
    {0x44, 0x28, 0x10, 0x28, 0x44},  // 'x'
    {0x0c, 0x50, 0x50, 0x50, 0x3c},  // 'y'
    {0x44, 0x64, 0x54, 0x4c, 0x44},  // 'z'
    {0x00, 0x08, 0x36, 0x41, 0x00},  // '{'
    {0x00, 0x00, 0x7f, 0x00, 0x00},  // '|'
    {0x00, 0x41, 0x36, 0x08, 0x00},  // '}'
    {0x08, 0x08, 0x2a, 0x1c, 0x08},  // '~' (approximation arrow)
    {0x00, 0x00, 0x00, 0x00, 0x00},  // DEL
};
#endif

int scale_of(Framebuffer::Font f) { return static_cast<int>(f); }

}  // namespace

void Framebuffer::copy_from(const Framebuffer& other) {
  if (this != &other) {
    std::memcpy(buf_, other.buf_, kSize);
  }
}

int Framebuffer::diff_pixels(const Framebuffer& other) const {
  int n = 0;
  for (size_t i = 0; i < kSize; ++i) {
    n += __builtin_popcount(static_cast<unsigned>(buf_[i] ^ other.buf_[i]));
  }
  return n;
}

void Framebuffer::clear() { std::memset(buf_, 0, sizeof(buf_)); }

void Framebuffer::set_pixel(int x, int y, bool on) {
  if (x < 0 || x >= kWidth || y < 0 || y >= kHeight) {
    return;
  }
  const size_t idx = static_cast<size_t>(y / 8) * kWidth + x;
  const uint8_t bit = static_cast<uint8_t>(1u << (y % 8));
  if (on) {
    buf_[idx] |= bit;
  } else {
    buf_[idx] &= static_cast<uint8_t>(~bit);
  }
}

bool Framebuffer::pixel(int x, int y) const {
  if (x < 0 || x >= kWidth || y < 0 || y >= kHeight) {
    return false;
  }
  return (buf_[static_cast<size_t>(y / 8) * kWidth + x] >> (y % 8)) & 1u;
}

void Framebuffer::fill_rect(int x, int y, int w, int h, bool on) {
  for (int yy = y; yy < y + h; ++yy) {
    for (int xx = x; xx < x + w; ++xx) {
      set_pixel(xx, yy, on);
    }
  }
}

void Framebuffer::fill_rect_dither(int x, int y, int w, int h,
                                   Dither pattern) {
  for (int yy = y; yy < y + h; ++yy) {
    for (int xx = x; xx < x + w; ++xx) {
      bool on = true;
      switch (pattern) {
        case Dither::kSolid:
          break;
        case Dither::kHalf:
          on = ((xx + yy) & 1) == 0;
          break;
        case Dither::kQuarter:
          on = (xx & 1) == 0 && (yy & 1) == 0;
          break;
      }
      if (on) {
        set_pixel(xx, yy, true);
      }
    }
  }
}

void Framebuffer::invert_rect(int x, int y, int w, int h) {
  for (int yy = y; yy < y + h; ++yy) {
    for (int xx = x; xx < x + w; ++xx) {
      if (xx < 0 || xx >= kWidth || yy < 0 || yy >= kHeight) {
        continue;
      }
      set_pixel(xx, yy, !pixel(xx, yy));
    }
  }
}

void Framebuffer::blit(int x, int y, const uint8_t* rows, int w, int h) {
  for (int row = 0; row < h; ++row) {
    const uint8_t bits = rows[row];
    for (int col = 0; col < w; ++col) {
      if ((bits >> (7 - col)) & 1u) {
        set_pixel(x + col, y + row, true);
      }
    }
  }
}

void Framebuffer::rect(int x, int y, int w, int h, bool on) {
  fill_rect(x, y, w, 1, on);
  fill_rect(x, y + h - 1, w, 1, on);
  fill_rect(x, y, 1, h, on);
  fill_rect(x + w - 1, y, 1, h, on);
}

void Framebuffer::draw_line(int x0, int y0, int x1, int y1, bool on) {
  int dx = x1 - x0;
  if (dx < 0) {
    dx = -dx;
  }
  int dy = y0 - y1;
  if (dy < 0) {
    dy = -dy;
  }
  dy = -dy;
  const int sx = x0 < x1 ? 1 : -1;
  const int sy = y0 < y1 ? 1 : -1;
  int err = dx + dy;
  for (;;) {
    set_pixel(x0, y0, on);
    if (x0 == x1 && y0 == y1) {
      break;
    }
    const int e2 = 2 * err;
    if (e2 >= dy) {
      err += dy;
      x0 += sx;
    }
    if (e2 <= dx) {
      err += dx;
      y0 += sy;
    }
  }
}

int Framebuffer::glyph_height(Font font) { return 7 * scale_of(font); }

int Framebuffer::text_width(const char* s, Font font) {
  int n = 0;
  while (s[n] != '\0') {
    ++n;
  }
  const int scale = scale_of(font);
  return n > 0 ? (n * 6 - 1) * scale : 0;
}

int Framebuffer::draw_text(int x, int y, const char* s, Font font) {
  const int scale = scale_of(font);
  int cx = x;
  for (const char* p = s; *p != '\0'; ++p) {
    const unsigned char c = static_cast<unsigned char>(*p);
    const uint8_t* glyph =
        kFont5x7[(c >= 32 && c < 128) ? c - 32 : 0];
    for (int col = 0; col < 5; ++col) {
      for (int row = 0; row < 7; ++row) {
        if ((glyph[col] >> row) & 1u) {
          fill_rect(cx + col * scale, y + row * scale, scale, scale, true);
        }
      }
    }
    cx += 6 * scale;
  }
  return cx - x;
}

void Framebuffer::ascii_row(int y, char* out) const {
  for (int x = 0; x < kWidth; ++x) {
    out[x] = pixel(x, y) ? '#' : '.';
  }
  out[kWidth] = '\0';
}

}  // namespace neon
